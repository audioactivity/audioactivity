<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_rx</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>4096/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center</value></param>
<param><key>value</key><value>18500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>fcc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, 100, 100, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>center_freq</key><value>center-deviation</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>fcc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, 100, 100, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>center_freq</key><value>center+deviation</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>2.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>"/dev/stdout"</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)/decim</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
</block>
<block>
<key>audioactivity_packet_decoder</key>
<param><key>id</key><value>audioactivity_packet_decoder_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>-1</value></param>
<param><key>compare</key><value>'abcdefghijklmnopqrstuvwxyz'</value></param>
<param><key>repeat</key><value>3</value></param>
<param><key>interleave</key><value>1</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audioactivity_packet_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>audioactivity_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
